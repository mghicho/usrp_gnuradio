<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>500000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>user_rx_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>rx_gain</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>max</key><value>90</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>90</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>user_rx_gain_0</value></param>
<param><key>value</key><value>rx_gain</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>90</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>user_tx_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>tx_gain</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>TX Gain</value></param>
<param><key>max</key><value>90</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>90</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>user_tx_gain_0</value></param>
<param><key>value</key><value>tx_gain</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>TX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>90</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ampl</value></param>
<param><key>label</key><value>TX BB amp</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>USRP device args</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>''</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0</value></param>
<param><key>addr</key><value>127.0.0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>server</key><value>False</value></param>
<param><key>port</key><value>12346</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_1</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>length</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>mtu</value></param>
<param><key>port</key><value>port</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>12346</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>psize</key><value>1470</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mtu</value></param>
<param><key>label</key><value>TCP Socket MTU</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>255</value></param>
</block>
<block>
<key>ofdm_radio</key>
<param><key>id</key><value>ofdm_radio_0</value></param>
<param><key>rate</key><value>1e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>TCP port</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>12345</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_antenna</value></param>
<param><key>label</key><value>RX antenna</value></param>
<param><key>short_id</key><value>A</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>TX/RX</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>RX freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>420e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_lo_offset</value></param>
<param><key>label</key><value>RX LO offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samps_per_sym</value></param>
<param><key>label</key><value>Samples/symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>label</key><value>TX freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>440e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>label</key><value>TX gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_lo_offset</value></param>
<param><key>label</key><value>TX LO offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>2*samp_rate</value></param>
<param><key>center_freq0</key><value>tx_freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>args</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>2*samp_rate</value></param>
<param><key>center_freq0</key><value>rx_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>args</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0.0001</value></param>
<param><key>title</key><value>RX</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0.02</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blks2_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>ofdm_radio_0</sink_block_id><source_key>pdus</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>ofdm_radio_0</source_block_id><sink_block_id>blocks_message_debug_0_0_1</sink_block_id><source_key>msg_out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>ofdm_radio_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>msg_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ofdm_radio_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msg_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ofdm_radio_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>ofdm_radio_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
