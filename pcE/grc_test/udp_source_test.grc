<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>mac_packet_deframer</key>
<param><key>id</key><value>mac_packet_deframer_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>threshold</key><value>0</value></param>
</block>
<block>
<key>mac_packet_to_pdu</key>
<param><key>id</key><value>mac_packet_to_pdu_0</value></param>
<param><key>dewhiten</key><value>True</value></param>
<param><key>output_invalid</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>mac_packet_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mac_packet_deframer_0</source_block_id><sink_block_id>mac_packet_to_pdu_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>mac_packet_to_pdu_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>pdu</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
